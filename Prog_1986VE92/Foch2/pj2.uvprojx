# Keil uVision project pj2.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.1.4
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: pj2 +hex
  c flags: uC99=1 wLevel=1
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c spec_1508pl10.c
software components: Device:Startup_MDR1986BE9x 1.3.1, Drivers:ADC 1.3.1, Drivers:BKP 1.3.1, Drivers:DAC 1.3.1, Drivers:I2C 1.3.1, Drivers:IWDG 1.3.1, Drivers:LIB 1.3.1, Drivers:PORT 1.3.1, Drivers:RST_CLK 1.3.1, Drivers:SSP 1.3.1, Drivers:TIMER 1.3.1, Drivers:UART 1.3.1
