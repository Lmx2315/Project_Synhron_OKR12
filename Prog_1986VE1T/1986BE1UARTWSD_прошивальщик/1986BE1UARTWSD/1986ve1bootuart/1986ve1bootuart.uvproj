# Keil uVision project 1986ve1bootuart.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: Cortex-M1 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M1")
  output: 1986ve1bootuart +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x20103400 size 0x800
  memory RVCT9: RAM 0x20103c00 size 0x400
  group Source Group 1
    ./: startup_bootuart.s bootuart.c
