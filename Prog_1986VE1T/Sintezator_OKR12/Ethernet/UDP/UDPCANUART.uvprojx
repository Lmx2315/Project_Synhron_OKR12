# Keil uVision project UDPCANUART.uvprojx, settings and files
target Управляющая программа (ARM-ADS)
  device: MDR1986BE1T Milandr
  pack: Keil.MDR1986BExx.1.4
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x8000) IRAM2(0x20100000,0x4000) CPUTYPE("Cortex-M1") CLOCK(12000000) ELITTLE
  output: proshivka +hex
  c flags: Optim=1 wLevel=1
  c include: .\inc;.\src\TCPIP\ARP;.\src\TCPIP\MAC;.\src\TCPIP\ICMP;.\src\TCPIP\IP;.\src\TCPIP\UDP;.\src\1986VE1T\CAN1;.\src\1986VE1T\ETHERNET;.\src\1986VE1T\PORTA;.\src\1986VE1T\PORTB;.\src\1986VE1T\PORTC;.\src\1986VE1T\PORTD;.\src\1986VE1T\PORTE;.\src\1986VE1T\PORTF;.\src\1986VE1T\RST_CLK;.\src;.\src\API\MemAPI;.\src\1986VE1T\TERMINAL;.\src\1986VE1T\DDS1508pl1t;.\src\1986VE1T\ADC
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x4000
  group Приложение
    ./src/: Application.c Startup.s
  group Драйверы
    ./src/1986VE1T/CAN1/: CAN1.c
    ./src/1986VE1T/PORTA/: PORTA.c
    ./src/1986VE1T/PORTB/: PORTB.c
    ./src/1986VE1T/ETHERNET/: ETHERNET.c
    ./src/1986VE1T/PORTC/: PORTC.c
    ./src/1986VE1T/PORTD/: PORTD.c
    ./src/1986VE1T/PORTE/: PORTE.c
    ./src/1986VE1T/PORTF/: PORTF.c
    ./src/1986VE1T/RST_CLK/: RST_CLK.c
    ./src/1986VE1T/UART1/: UART1.c
    ./src/1986VE1T/UART2/: UART2.c
    ./src/1986VE1T/TERMINAL/: TERMINAL.c
    ./src/1986VE1T/DDS1508pl1t/: DDS1508pl1t.c
    ./src/1986VE1T/ADC/: ADC.c
  group Протоколы
    ./src/TCPIP/ARP/: ARP.c
    ./src/TCPIP/ICMP/: ICMP.c
    ./src/TCPIP/IP/: IP.c
    ./src/TCPIP/UDP/: UDP.c
    ./src/TCPIP/MAC/: MAC.c
  group Функции
    ./: MemAPI.c
